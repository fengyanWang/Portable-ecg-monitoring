# Keil uVision project OLED.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OLED +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\OLED;..\HARDWARE\Function;..\HARDWARE\BEEP;..\HARDWARE\DS18B20;..\HARDWARE\RTC;..\HARDWARE\HC05;..\HARDWARE\USART2;..\HARDWARE\SD;..\HARDWARE\SPI;..\HARDWARE\Malloc;..\HARDWARE\ADS1293_Driver;..\HARDWARE\SPI_UserDriver;..\HARDWARE\UartCommunicate;..\HARDWARE\Init;..\HARDWARE\DateProce
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/Function/: function.c
    ../HARDWARE/KEY/: key.c exti.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/HC05/: hc05.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/SD/: MMC_SD.C
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/Malloc/: malloc.c
    ../HARDWARE/ADS1293_Driver/: ADS1293_Driver.c
    ../HARDWARE/SPI_UserDriver/: SPI_UserDriver.c
    ../HARDWARE/UartCommunicate/: uart_communicate.c
    ../HARDWARE/Init/: stm32f10x_init.c
    ../HARDWARE/DateProce/: DateProce.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_tim.c stm32f10x_spi.c
